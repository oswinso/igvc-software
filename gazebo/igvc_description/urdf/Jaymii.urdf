Commit message: work

File: gazebo/igvc_description/urdf/Jaymii.urdf (robot description, URDF)
Before this commit: robot Jaymii, 12 links, 11 joints
Joints:
- joint imu_to_center_camera: origin xyz=-.056 0 .937 rpy=0 .8 0 -> xyz=-.056 0 .937 rpy=0 .6 0
